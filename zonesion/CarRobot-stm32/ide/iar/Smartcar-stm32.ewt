<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Smartcar-stm32</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>serial-shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\apps\serial-shell\serial-shell.c</name>
      </file>
    </group>
    <group>
      <name>shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\apps\shell\shell.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>core</name>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\dev\leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\dev\nullradio.c</name>
      </file>
    </group>
    <group>
      <name>lib</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\crc16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\gcr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\ifft.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\me.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\me_tabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\memb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\mmem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\petsciiconv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\print-stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\ringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\sensors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\settings.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\strncasecmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\trickle-timer.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>mac</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\contikimac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\csma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\cxmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\frame802154.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\framer-802154.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\framer-nullmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\lpp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\mac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\nullmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\nullrdc-noframer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\nullrdc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\phase.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\sicslowmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\mac\xmac.c</name>
        </file>
      </group>
      <group>
        <name>rime</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rime\rimeaddr.c</name>
        </file>
      </group>
      <group>
        <name>rpl</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-dag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-ext-header.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-icmp6.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-mrhof.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-of0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl-timers.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\core\net\rpl\rpl.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\dhcpc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\hc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\nbr-table.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\netstack.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\packetbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\packetqueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\psock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\queuebuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\rawpacket-udp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\resolv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\sicslowpan.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\simple-udp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\slipdev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\tcpdump.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\tcpip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uaodv-rt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uaodv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-ds6-nbr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-ds6-route.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-ds6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-fw-drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-fw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-icmp6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-nd6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-neighbor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-over-mesh.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-packetqueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-split.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip-udp-packet.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uip_arp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\net\uiplib.c</name>
      </file>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\arg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\autostart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\compower.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\ctimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\energest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\etimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\mt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\procinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\profile-aggregates.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\profile.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\rtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\stimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\sys\timer.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>cpu</name>
    <group>
      <name>arm</name>
      <group>
        <name>stm32f407</name>
        <group>
          <name>cmsis</name>
        </group>
        <group>
          <name>fwlib</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\misc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_can.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_crc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_des.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_tdes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dac.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dbgmcu.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dcmi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dma2d.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_exti.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_flash_ramfunc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_fsmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash_md5.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash_sha1.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_iwdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_ltdc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_pwr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rcc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_sai.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_sdio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_syscfg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_tim.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_usart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_wwdg.c</name>
          </file>
        </group>
        <group>
          <name>startup</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\startup\startup_stm32f40xx.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\startup\system_stm32f4xx.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\adc3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\clock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\IIC3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\leds-arch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\my.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\rtimer-arch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\spi1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\spi2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\spi3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\stm32f4xx_conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\uart1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\uart2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\uart4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\usart3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\usart6.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\cpu\arm\stm32f407\watchdog.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>zonesion</name>
    <group>
      <name>app</name>
      <file>
        <name>$PROJ_DIR$\..\..\app\alarm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\autoapps.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\ble.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\gsm2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\helloworld.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\lcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\qrcode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\sample.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\user.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\utcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\zxbee.c</name>
      </file>
    </group>
    <group>
      <name>commom</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\dev\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\dev\nvic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\dev\pcf8563.c</name>
      </file>
    </group>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\..\..\dev\adc_key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\bh1750.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\E18-D80NK.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\flamag2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\font-car.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\GPS.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\htu21d.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\ili93xx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\infrared.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\mg2639.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\motor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\SteeringEngine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\Ultrasonic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\dev\w25qxx.c</name>
      </file>
    </group>
    <group>
      <name>qrcode</name>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\bitstream.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\mask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\mmask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\mqrspec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\QR_Encode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\qrencode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\qrinput.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\qrspec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\rscode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\qrencode\split.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\contiki-conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\contiki-main.c</name>
    </file>
  </group>
</project>


