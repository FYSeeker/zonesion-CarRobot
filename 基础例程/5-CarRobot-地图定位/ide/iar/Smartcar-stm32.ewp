# IAR project Smartcar-stm32.ewp, settings and files
configuration Smartcar-stm32 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40_41xxx; _DLIB_FILE_DESCRIPTOR=1; USE_STDPERIPH_DRIVER; STM32F40X_MD; xWITH_IPV6; xWITH_II_802154; xWITH_RPL; IHD_BASIC_B
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\cpu\arm\stm32f407\fwlib\inc; ..\..\..\..\cpu\arm\stm32f407\startup; ..\..\..\..\cpu\arm\stm32f407\cmsis; ..\..\..\..\cpu\arm\stm32f407; ..\..\..\..\core; ..\..\..\..\core\net; ..\..\..\..\core\net\mac; ..\..\..\..\core\net\rpl; ..\..\..\..\core\net\rime; ..\..\..\common; ..\..\dev; ..\..\..\common\dev; ..\..\app; ..\..\qrencode; ..\..\..\..\apps\shell
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Smartcar-stm32.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/serial-shell
    ../../../../apps/serial-shell/: serial-shell.c
  group app/shell
    ../../../../apps/shell/: shell.c
  group core
    ../../../../core/ctk/: ctk.h
  group core/dev
    ../../../../core/dev/: leds.c nullradio.c
  group core/lib
    ../../../../core/lib/: assert.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c strncasecmp.c trickle-timer.c
  group core/net
    ../../../../core/net/: dhcpc.c hc.c nbr-table.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c rawpacket-udp.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    ../../../../core/net/mac/: contikimac.c csma.c cxmac.c frame802154.c framer-802154.c framer-nullmac.c lpp.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c sicslowmac.c xmac.c
  group core/net/rime
    ../../../../core/net/rime/: rimeaddr.c
  group core/net/rpl
    ../../../../core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    ../../../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile-aggregates.c profile.c rtimer.c stimer.c timer.c
  group cpu/arm/stm32f407
    ../../../../cpu/arm/stm32f407/: adc3.c clock.c debug.c IIC3.c leds-arch.c my.h rtimer-arch.c spi1.c spi2.c spi3.c stm32f4xx_conf.h uart1.c uart2.c uart4.c usart3.c usart6.c watchdog.c
  group cpu/arm/stm32f407/fwlib
    ../../../../cpu/arm/stm32f407/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group cpu/arm/stm32f407/startup
    ../../../../cpu/arm/stm32f407/startup/: startup_stm32f40xx.s system_stm32f4xx.c
  group zonesion
    ../../: contiki-conf.h contiki-main.c
  group zonesion/app
    ../../app/: autoapps.c ble.c config.c gsm2.c helloworld.c lcd.c qrcode.c sample.c user.c utcp.c zxbee.c
  group zonesion/commom
    ../../../common/dev/: adc.c nvic.c pcf8563.c
  group zonesion/dev
    ../../dev/: adc_key.c bh1750.c E18-D80NK.c flamag2.c flash.c fsmc.c GPS.c htu21d.c ili93xx.c infrared.c led.c mg2639.c motor.c rtc.c SteeringEngine.c Ultrasonic.c w25qxx.c
  group zonesion/qrcode
    ../../qrencode/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
